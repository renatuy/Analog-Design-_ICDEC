v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/lab_pin.sym} 470 50 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 330 -100 0 1 {name=p2 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 470 -60 0 0 {name=p3 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 70 0 1 {name=p4 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 470 -80 0 0 {name=p5 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 470 -100 2 1 {name=p6 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 470 90 0 0 {name=p7 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 470 70 0 0 {name=p8 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 470 30 0 0 {name=p9 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 470 -40 0 0 {name=p10 sig_type=std_logic lab=RS}
C {devices/lab_pin.sym} 330 -80 0 1 {name=p11 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 330 -60 0 1 {name=p12 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 330 -40 0 1 {name=p13 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 330 30 0 1 {name=p14 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 330 50 0 1 {name=p15 sig_type=std_logic lab=OUT}
C {/home/hisyam/opamp/xschem/pmoscs.sym} 180 -70 0 0 {name=x3}
C {/home/hisyam/opamp/xschem/nmoscs2.sym} 180 50 0 0 {name=x2}
C {/home/hisyam/opamp/xschem/nmoscs.sym} 620 -70 0 1 {name=x1}
C {devices/lab_pin.sym} 770 30 0 1 {name=p16 sig_type=std_logic lab=VIN}
C {/home/hisyam/opamp/xschem/pmosdif.sym} 620 60 0 1 {name=x4}
C {devices/lab_pin.sym} 770 50 2 0 {name=p17 sig_type=std_logic lab=VIP}
C {devices/iopin.sym} 880 -70 0 0 {name=p18 lab=VDD}
C {devices/iopin.sym} 880 -40 0 0 {name=p19 lab=VIN}
C {devices/iopin.sym} 880 -10 0 0 {name=p20 lab=VIP}
C {devices/iopin.sym} 880 20 0 0 {name=p21 lab=OUT}
C {devices/iopin.sym} 880 50 0 0 {name=p22 lab=GND}
C {devices/iopin.sym} 880 90 0 0 {name=p23 lab=RS}
